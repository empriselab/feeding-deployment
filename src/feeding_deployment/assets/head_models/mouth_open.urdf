Commit message: verified cleaned up version with real robot

File: src/feeding_deployment/assets/head_models/mouth_open.urdf (robot description, URDF)
Before this commit: robot head_model, 1 links, 0 joints
Links:
- link headbase: geometry visual mesh filename=mouth_open_neck_origin.obj
