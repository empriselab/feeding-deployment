Commit message: cleaning up assets

File: src/feeding_deployment/assets/table/table.urdf (robot description, URDF)
Before this commit: robot table, 1 links, 0 joints
Links:
- link table: geometry collision mesh filename=simplified_table.obj; visual mesh filename=table.obj
