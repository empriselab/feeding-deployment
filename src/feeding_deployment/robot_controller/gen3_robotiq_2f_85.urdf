Commit message: server side changes

File: src/feeding_deployment/robot_controller/gen3_robotiq_2f_85.urdf (robot description, URDF)
Before this commit: robot gen3_robotiq_2f_85, 11 links, 10 joints
Links:
- link robotiq_arg2f_base_link: mass 0.78 -> 1.6
