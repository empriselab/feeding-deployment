Commit message: mass tweaks

File: src/feeding_deployment/robot_controller/urdfs/hack_gen3_robotiq_2f_85_wipe.urdf (robot description, URDF)
Before this commit: robot gen3_robotiq_2f_85_feeding, 14 links, 13 joints
Links:
- link robotiq_arg2f_base_link: mass 1.6 -> 1.3
